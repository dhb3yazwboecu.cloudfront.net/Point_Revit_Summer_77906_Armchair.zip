Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-10-02T18:39:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190412_1200(x64) - Exporter 20.0.1.2 - Alternate UI 20.0.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 02 18:39:43 2020 * Host: RASHID-PC * Database: C:\Users\mohdr\AppData\Local\Temp\c6d6c294-86b9-4bab-bbc6-b4ffcf9aa0c6\747c781e-8ae2-49eb-807e-6b7b133f2c40\ifc * Database version: 5507 * Database creation date: Fri Oct 02 18:39:32 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 02 18:39:33 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 02 18:39:33 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: Summer Arm Chair, Summer Arm Chair:Summer Arm Chair:205306
In: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Summer
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Summer Arm Chair
